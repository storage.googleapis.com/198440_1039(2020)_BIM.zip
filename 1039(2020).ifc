Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2020-06-09T13:24:07
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Jun 09 13:24:07 2020 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\{E4FA27F6-5B3B-43A4-8AB7-5CEA779F1E3D}\ifc * Database version: 5507 * Database creation date: Tue Jun 09 13:24:06 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Jun 09 13:24:07 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Jun 09 13:24:07 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 1039F Kitchen faucet with dishwasher valve, 1039F(2020):1039F Kitchen faucet with dishwasher valve:331482
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions(Type) - InletConnectionSize: 10 mm; Projection: 178 mm
Type - General(Type) - Author: Convergo AB; BIMObjectName: 1039F(2020); ConvergoRefNr: 0087-1804-0025-FI; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for sinks; NBSReference: 45-35-70/345; ProductInformation: Kitchen faucet with high spout and dishwasher valve with ceramic cartridge 90° rotation for ON/OFF; Revision: 3; Uniclass2: Pr_40_30_96_96; Uniclass2015Description: Sink manual water supply sets; Uniclass2015Reference: Pr_40_20_87_82; Version: 3; VersionDate: 01/05/2020
Type - Green Building Properties(Type) - Approval KIWA SE Type Approval: 1491; Customs Code: 84818011; EAN Number: 6414150078958; EN Standard: EN 817; LVI Number: 6219127; NRF Number: 4200416; RSK Number: 8310574; URL KIWA SE Type Approval: http://static.oras.com/SETypeApproval/1039F; VVS Number: 705898604
Type - Identity Data(Type) - 2D/3D/BIM Files URL: http://static.oras.com/bim/1039F; Catalog Drawing URL: http://static.oras.com/catdrw/1039F; Class: Single lever; Dimension Drawing URL: http://static.oras.com/dimdrw/1039F; FDV Document URL: http://www.oras.com/datasheet/1039F/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/1039F; Group: Kitchen faucets; Long Marketing: Kitchen faucet with high spout and dishwasher valve with ceramic valve 90° rotation for ON/OFF. Spout’s swing angle is factory preset at 120° (can be limited to 0° or 60°). There are also in-built limitation options for water temperature and maximum flow-rate. F = with flexible pipes; Manufacturer: Oras; Market: INT;NOR;SWE;POL;RUS;EST;LTU;LVA;UKR; Model: 1039F Kitchen faucet with dishwasher valve; Name_en: 1039F Kitchen faucet with dishwasher valve; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package external Dimensions: 754 x 334 x 63; Package Weight: 2.14 kg; Product Code: 1039F; Product Datasheet: http://www.oras.com/datasheet/1039F/en; Product Family: Oras Safira; Product Image URL: http://static.oras.com/image/1039F; Product URL: http://static.oras.com/1039F; Type Name: 1039F Kitchen faucet with dishwasher valve
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Advanced Features: 3S-Installation; Connection: Flexible Inlet Pipes; Connection Size: G3/8; Dishwasher Valve: Dishwasher valve; Flow Rate At 300kPa: 0.00706293 m3/s; Installation and Maintenance: http://static.oras.com/manual/1039F; Installation Type: Deck mounted; Lever Handle: Lever with H+C symbol; Max. Hot Water Supply: 80 kg/K/s3; Mechanical Parts: 40Cartridge; Mounting Holes: 1 Mounting Hole; Noise Class: I (ISO 3822); Pressure Loss With Flow 02ls: 290000 Pa; Spare Parts: http://static.oras.com/sp/1039F; Spout Swivel Range: 120° (60° / 0°); Spout Type: Swivel spout; Temperature: Temperature limiter
Type - Other(Type) - AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; Category: Kitchen; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 1039F(2020); Features: Single lever; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 1039F; Name: 1039F Kitchen faucet with dishwasher valve; ReplacementCost: n/a; Shape: Sculptured; Size: 55x260x340 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 1039F; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 1039F Kitchen faucet with dishwasher valve
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.12186 m2; Volume: 0.00477761 m3
Identity Data - Mark: 7
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 1039F(2020): 1039F Kitchen faucet with dishwasher valve; Family and Type: 1039F(2020): 1039F Kitchen faucet with dishwasher valve; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 1039F(2020): 1039F Kitchen faucet with dishwasher valve; Type Id: 1039F(2020): 1039F Kitchen faucet with dishwasher valve; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
